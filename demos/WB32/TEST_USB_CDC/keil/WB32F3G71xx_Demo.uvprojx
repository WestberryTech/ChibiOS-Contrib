# Keil uVision project WB32F3G71xx_Demo.uvprojx, settings and files
target WB32F3G71xx_Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Template +hex
  c flags: Optim=3 oTime=1 uC99=1 wLevel=2
  c define: CORTEX_USE_FPU=0 __heap_base__=Image$$$$RW_IRAM1$$$$ZI$$$$Limit __heap_end__=Image$$$$RW_IRAM2$$$$Base
  c misc: -USTM32F303xC -DTEST_CFG_SIZE_REPORT=0
  c include: ..\;..\cfg;..\..\..\..\..\chibios\os\license;..\..\..\..\os\common\startup\ARMCMx\devices\WB32F3G71xx;..\..\..\..\..\chibios\os\common\ext\ARM\CMSIS\Core\Include;..\..\..\..\os\common\ext\CMSIS\WB32\WB32F3G71xx;..\..\..\..\..\chibios\os\common\ports\ARMCMx;..\..\..\..\..\chibios\os\common\ports\ARMCMx\compilers\RVCT;..\..\..\..\..\chibios\os\rt\include;..\..\..\..\..\chibios\os\oslib\include;..\..\..\..\..\chibios\os\hal\osal\rt-nil;..\..\..\..\..\chibios\os\hal\include;..\board;..\..\..\..\..\chibios\os\hal\ports\common\ARMCMx;..\..\..\..\os\hal\ports\WB32\WB32F3G71xx;..\..\..\..\os\hal\ports\WB32\LLD\TIMv1;..\..\..\..\os\hal\ports\WB32\LLD\GPIOv1;..\..\..\..\os\hal\ports\WB32\LLD\DMAv1;..\..\..\..\os\hal\ports\WB32\LLD\I2Cv1;..\..\..\..\os\hal\ports\WB32\LLD\UARTv1;..\..\..\..\os\hal\ports\WB32\LLD\SPIv1;..\..\..\..\os\hal\ports\WB32\LLD\USBv1;..\..\..\..\..\chibios\os\various\shell;..\..\..\..\..\chibios\os\hal\lib\streams;..\..\..\..\..\chibios\test\rt\source\test;..\..\..\..\..\chibios\test\lib;..\..\..\..\..\chibios\test\oslib\source\test
  asm misc: --cpreproc --cpreproc_opts=-D,CORTEX_USE_FPU=0
  asm include: ..\;..\cfg;..\..\..\..\..\os\license;..\..\..\..\..\os\common\startup\ARMCMx\devices\STM32F3xx;..\..\..\..\..\os\common\ports\ARMCMx;..\..\..\..\..\os\hal\boards\ST_STM32F3_DISCOVERY
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT6: RAM 0x10000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x8ffc
  memory RVCT10: RAM 0x20008ffc size 0x4
  group license
    ../../../../../chibios/os/license/: chcustomer.h chlicense.h chversion.h
  group startup
    ../../../../../chibios/os/common/startup/ARMCMx/compilers/RVCT/: cstartup.s vectors.s
    ../../../../os/common/startup/ARMCMx/devices/WB32F3G71xx/: cmparams.h
  group cmsis
    ../../../../../chibios/os/common/ext/ARM/CMSIS/Core/Include/: core_cm3.h
    ../../../../os/common/ext/CMSIS/WB32/WB32F3G71xx/: wb32f3g71xx.h
  group kernel port
    ../../../../../chibios/os/common/ports/ARMCMx/: chcore.c chcore.h chcore_timer.h chcore_v7m.h mpu.h chcore_v7m.c
    ../../../../../chibios/os/common/ports/ARMCMx/compilers/RVCT/: chtypes.h chcoreasm_v7m.s
  group kernel
    ../../../../../chibios/os/rt/include/: ch.h chalign.h chchecks.h chcond.h chdebug.h chdynamic.h chevents.h chmsg.h chmtx.h chregistry.h chrestrictions.h chschd.h chsem.h chstats.h chsys.h chsystypes.h chthreads.h chtime.h chtm.h chtrace.h chvt.h
    ../../../../../chibios/os/rt/src/: chcond.c chdebug.c chdynamic.c chevents.c chmsg.c chmtx.c chregistry.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c chtrace.c chvt.c
  group oslib
    ../../../../../chibios/os/oslib/include/: chbsem.h chdelegates.h chfactory.h chjobs.h chlib.h chmboxes.h chmemcore.h chmemheaps.h chmempools.h chobjcaches.h chobjfifos.h chpipes.h
    ../../../../../chibios/os/oslib/src/: chdelegates.c chfactory.c chmboxes.c chmemcore.c chmemheaps.c chmempools.c chobjcaches.c chpipes.c
  group osal
    ../../../../../chibios/os/hal/osal/rt-nil/: osal.c osal.h
  group hal
    ../../../../../chibios/os/hal/include/: hal.h hal_adc.h hal_buffers.h hal_can.h hal_channels.h hal_crypto.h hal_dac.h hal_efl.h hal_files.h hal_flash.h hal_gpt.h hal_i2c.h hal_i2s.h hal_icu.h hal_ioblock.h hal_mac.h hal_mii.h hal_mmc_spi.h hal_mmcsd.h hal_objects.h hal_pal.h hal_persistent.h hal_pwm.h hal_queues.h hal_rtc.h hal_sdc.h hal_serial.h hal_serial_usb.h hal_sio.h hal_spi.h hal_st.h hal_streams.h hal_trng.h hal_uart.h hal_usb.h hal_usb_cdc.h hal_wdg.h hal_wspi.h
    ../../../../../chibios/os/hal/src/: hal.c hal_adc.c hal_buffers.c hal_can.c hal_crypto.c hal_dac.c hal_efl.c hal_flash.c hal_gpt.c hal_i2c.c hal_i2s.c hal_icu.c hal_mac.c hal_mmc_spi.c hal_mmcsd.c hal_pal.c hal_pwm.c hal_queues.c hal_rtc.c hal_sdc.c hal_serial.c hal_serial_usb.c hal_sio.c hal_spi.c hal_st.c hal_trng.c hal_uart.c hal_usb.c hal_wdg.c hal_wspi.c
  group hal_port
    ../../../../../chibios/os/hal/ports/common/ARMCMx/: nvic.c
    ../../../../os/hal/ports/WB32/LLD/GPIOv1/: hal_pal_lld.c
    ../../../../os/hal/ports/WB32/LLD/TIMv1/: hal_st_lld.c hal_pwm_lld.c hal_icu_lld.c hal_gpt_lld.c
    ../../../../os/hal/ports/WB32/WB32F3G71xx/: hal_lld.c
    ../../../../os/hal/ports/WB32/LLD/I2Cv1/: hal_i2c_lld.c
    ../../../../os/hal/ports/WB32/LLD/UARTv1/: hal_uart_lld.c
    ../../../../os/hal/ports/WB32/LLD/SPIv1/: hal_spi_lld.c
    ../../../../os/hal/ports/WB32/LLD/USBv1/: hal_usb_lld.c
    ../../../../../chibios/os/hal/include/: hal.h
  group board
    ../board/: board.c board.h
  group test
    ../../../../../chibios/test/oslib/source/test/: oslib_test_root.c oslib_test_sequence_001.c oslib_test_sequence_002.c oslib_test_sequence_003.c oslib_test_sequence_004.c oslib_test_sequence_005.c oslib_test_sequence_006.c oslib_test_sequence_007.c oslib_test_sequence_008.c oslib_test_sequence_009.c
    ../../../../../chibios/test/lib/: ch_test.c
    ../../../../../chibios/test/rt/source/test/: rt_test_root.c rt_test_sequence_001.c rt_test_sequence_002.c rt_test_sequence_003.c rt_test_sequence_004.c rt_test_sequence_005.c rt_test_sequence_006.c rt_test_sequence_007.c rt_test_sequence_008.c rt_test_sequence_009.c rt_test_sequence_010.c rt_test_sequence_011.c
  group demo
    ../: main.c usbcfg.c
    ../cfg/: chconf.h halconf.h mcuconf.h
  group various
    ../../../../../chibios/os/various/shell/: shell.c shell_cmd.c
  group streams
    ../../../../../chibios/os/hal/lib/streams/: chprintf.c memstreams.c nullstreams.c
